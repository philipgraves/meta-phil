FILESEXTRAPATHS_prepend := "${THISDIR}/busybox:"

SRC_URI += " \
	    file://busybox_utilities.cfg \
           "

